# Keil uVision project Sensor_collector.uvprojx, settings and files
target LAN8720a (ARM-ADS)
  device: STM32F107RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sensor_collector +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\CORE;..\..\FWLIB\STM32F10x_ETHLib\inc;..\..\FWLIB\STM32F10x_FWLib\inc;..\..\HARDWARE\I2C;..\..\HARDWARE\KEY;..\..\HARDWARE\LAN8720;..\..\HARDWARE\LCD;..\..\HARDWARE\LED;..\..\HARDWARE\SD2405;..\..\HARDWARE\SPI;..\..\HARDWARE\SRAM;..\..\HARDWARE\TIMER;..\..\HARDWARE\W25Q64;..\..\LWIP\arch;..\..\LWIP;..\..\LWIP\lwip-1.4.1\src\include;..\..\LWIP\lwip-1.4.1\src\include\ipv4;..\..\LWIP\lwip-1.4.1\src\include\netif;..\..\LWIP\lwip_app\lwip_comm;..\..\SYSTEM\delay;..\..\SYSTEM\sys;..\..\SYSTEM\usart;..\..\MALLOC;..\..\USMART;..\..\HARDWARE\EXTI_WAKUP;..\..\HARDWARE\PWR_DOWN;..\..\HARDWARE\GPIO;..\..\HARDWARE\ADC;..\..\HARDWARE\RTC;..\..\HARDWARE\WDG;..\..\UCOSII\CONFIG;..\..\UCOSII\CORE;..\..\UCOSII\PORT;..\..\LWIP\lwip_app\tcp_client;..\..\LWIP\lwip_app\tcp_server
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../src/: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLIB
    ../../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ETHLIB
    ../../FWLIB/STM32F10x_ETHLib/src/: stm32_eth.c
  group SYSTEM
    ../../SYSTEM/sys/: sys.c
    ../../SYSTEM/usart/: usart.c
    ../../SYSTEM/delay/: delay.c
  group HARDWARE
    ../../HARDWARE/LAN8720/: lan8720.c
    ../../HARDWARE/TIMER/: timer.c
    ../../HARDWARE/ADC/: adc.c
  group MALLOC
    ../../MALLOC/: malloc.c
  group LWIP_APP
    ../../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../LWIP/lwip_app/tcp_client/: tcp_client.c
    ../../LWIP/lwip_app/tcp_server/: tcp_server.c
  group LWIP_NETIF
    ../../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group UCOSII_CORE
    ../../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII_CONFIG
    ../../UCOSII/CONFIG/: includes.h os_cfg.h
